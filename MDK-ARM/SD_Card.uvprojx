# Keil uVision project SD_Card.uvprojx, settings and files
target SD_Card (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_Card
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;     C:\Users\Admin\STM32Cube\Repository\STM32Cube_FW_F1_V1.3.0\Drivers\STM32F1xx_HAL_Driver\Inc;     C:\Users\Admin\STM32Cube\Repository\STM32Cube_FW_F1_V1.3.0\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;     C:\Users\Admin\STM32Cube\Repository\STM32Cube_FW_F1_V1.3.0\Middlewares\Third_Party\FatFs\src;     C:\Users\Admin\STM32Cube\Repository\STM32Cube_FW_F1_V1.3.0\Drivers\CMSIS\Include;     C:\Users\Admin\STM32Cube\Repository\STM32Cube_FW_F1_V1.3.0\Drivers\CMSIS\Device\ST\STM32F1xx\Include;    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Drivers/STM32F1xx_HAL_Driver/Inc;    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Middlewares/Third_Party/FatFs/src;    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Drivers/CMSIS/Include;    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: stm32f1xx_it.c main.c user_diskio.c stm32f1xx_hal_msp.c fatfs.c SD.c
  group Middlewares/FatFs
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c
  group Drivers/CMSIS
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.3.0/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
